# Evitar que el kernel busque dependencias de gráficos durante la compilación
PACKAGECONFIG:remove = "amdgpu"